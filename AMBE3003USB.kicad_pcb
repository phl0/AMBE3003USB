# Repository phl0/AMBE3003USB

File README.md:

# AMBE3003USB

This is a homebrew evaluation board for AMBE-3000 and AMBE-3003 Chips. It can be used as a replacement for USB-3003 devices to work as a transcoder for [XLX](https://github.com/LX3JL/xlxd) reflectors. This board is supported by the AMBEd daemon from version 1.2 onwards.

## Version 1.0

This is the initial version. Apparently it has two errors: The power supply is faulty due to R42 being to small in value. Bypassing the resistor works basically. The 1v9 rail draws to much power resulting in U5 running hot. 
The second issue is that this revision does not support hardware reset of the AMBE-3003 CPU. Soft reset does not work 100% reliably. In this case only un- and re-plugging the device works.

This is the link to the [Mouser project](https://www.mouser.com/ProjectManager/ProjectDetail.aspx?AccessID=42f49e97ec) shopping cart.

**This version is not recommended for (re-)production!**

## Version 1.1

The power supply has been redesigned. An additional transistor has been added to allow for a hardware reset using the DTR pin of the FT-232RL. This needs code changes in the XLX code. Additionally there have been added some more pins to the pin header that allow for configuring parity for AMBE-3000 chips by jumper.

Testing this version revealed an issue with missing pull-up resistor on the PWREN signal. That results in the voltage regulator not beeing activated. Quick fix is to add a 10k SMD resistor from bottom pin of R4 to anode of C5 (5v0). This is going to be fixed in revision 1.2.

This is the link to the [Mouser project](https://www.mouser.com/ProjectManager/ProjectDetail.aspx?AccessID=05fa8acc46) shopping cart.

**This version is not recommended for (re-)production!**

## Version 1.2

A 10k resistor (R22) was added to the schematics and board layout. 

This is the link to the [Mouser project](https://www.mouser.com/ProjectManager/ProjectDetail.aspx?AccessID=9071144aec) shopping cart.

**This version has not been tested yet. Use at your own risk.**

# Usage

## Flashing FT232

After building the board you have to flash the onboard FT-232 USB converter. The AMBEd expects to find this device with product ID "DF2ET-3003". The product ID can be flashed with the original FTprog by FTDI or using [ft232r_prog](http://rtr.ca/ft232r/) (command is ./ft232r_prog --product "DF2ET-3003").

## Setting Jumpers

* VSET has to be set to 1v9 for an AMBE-3003 chip (1v8 for AMBE-3000).
* SEQ needs to be LDO2, LDO1
* PARITY_ENABLE is ignored by an AMBE-3003 (disabled for AMBE-3000)
* IF_SELECT has to be set to UART (being IF_SELECT0 and IF_SELECT2 enabled, IF_SELECT1 disabled)
* DTX_ENABLE disabled
* NS_ENABLE disabled
* CP_ENABLE disabled
* CP_SELECT disabled
* SCOM_RATE has to be configured for 921,600 bit/s (which is SCOM_RATE0 and SCOM_RATE2 enabled, SCOM_RATE1 disabled)
* RATE settings are ignored in UART mode. No need for jumpers though

* HARD_RESET can be enabled by setting J5. Otherwise the code relies on a software reset only

* SK_ENABLE not used by AMBE-3003
* ES_ENABLE not used by AMBE-3003
* EC_ENABLE not used by AMBE-3003

## Drivers

If using in combination with XLX/AMBEd make sure that the operating system does not load the commonly used ftdi_sio kernel module to provide an USB-serial interface. The AMBEd makes use of the ft2xx direct access driver by FTDI with does not work if the kernel module is loaded. Hints on how this can be accomplished can be found in my [Blog](https://www.florian-wolters.de/blog/2017/08/18/excluding-ft-232-from-ftdi-sio-driver/).

# Contributors

This is the list of contributors. Thank you for your additions:

* Mathis, DB9MAT

# License

This project is released under the Creative Commons Attribution-NonCommercial-ShareAlike 3.0 (CC-BY-NC-SA 3.0, https://creativecommons.org/licenses/by-nc-sa/3.0/) license. You may edit and share it as you like, as long as credit is given and the license is not changed. You can build as many boards for you and your friends as you like and you can even sell it to them to cover your costs, **however it is strictly forbidden to turn this into a commercial product! You are not allowed to build and sell these boards for profit!**

## KiCad design AMBE3003USB.kicad_pcb

Parts:
C1, C4, C8, C18: 10n; C_0603_HandSoldering; MPN GRM188R70J103KA01D
C2, C3: 10u; C_0603_HandSoldering; MPN GRM188R60J106ME47D
C5, C6, C7: 10u; TantalC_SizeA_EIA-3216_HandSoldering; MPN T495A106K016ATE1K7
C9, C10, C11, C12, C14, C15, C17, C19, C20, C21, C22, C23, C24, C25, C28: 100n; C_0603_HandSoldering; MPN GRM188R70J104KA01D
C13, C16: 47p; C_0603_HandSoldering; MPN 06036A470JAT2A
C26, C27: 1u; TantalC_SizeA_EIA-3216_HandSoldering; MPN T495A105K020ATE3K0
C29: 4u7; TantalC_SizeA_EIA-3216_HandSoldering; MPN T495A475K020ATE1K8
D1: green; LED_0603; MPN 150060VS75000
D2: yellow; LED_0603; MPN 150060YS75000
D3: red; LED_0603; MPN 150060SS75000
J1: McBSP; Pin_Header_Straight_2x04; MPN M20-9980445
J2: USB_OTG; USB_Mini-B; MPN 67503-1020
J4: CODEC; Pin_Header_Straight_2x05; MPN M20-9980545
L1: 100MHz; L_0603_HandSoldering; MPN BLM18KG471BH1D
P1: GND; Pin_Header_Straight_1x17; MPN M20-9991746
P2: Config; Pin_Header_Straight_1x17; MPN M20-9991746
P3: 3v3; Pin_Header_Straight_1x17; MPN M20-9991746
P4: VSET; Pin_Header_Straight_1x03; MPN M20-9990346
P5: HARD RESET; Pin_Header_Straight_1x02; MPN M20-9990246
P6: SEQ; Pin_Header_Straight_1x03; MPN M20-9990346
P7: 3v3; Pin_Header_Straight_1x03; MPN M20-9990346
P8: ACONF; Pin_Header_Straight_1x03; MPN M20-9990346
P9: GND; Pin_Header_Straight_1x03; MPN M20-9990346
Q1: BC847; SOT-23_Handsoldering; MPN BC847BLT1G
R1, R20: 5.1; R_0603_HandSoldering; MPN RC0603FR-075R11L
R2: 3k74; R_0603_HandSoldering; MPN RC0603FR-073K74L
R3, R21, R22, R33: 10k; R_0603_HandSoldering; MPN RC0603FR-0710KL
R4, R5, R27: 24k; R_0603_HandSoldering; MPN RC0603FR-0724KL
R6, R7, R8, R9, R10, R11, R12, R13, R14, R15, R16, R17, R18, R19: 0R; R_0603_HandSoldering; MPN RC0603FR-070RL
R25, R26: 27; R_0603_HandSoldering; MPN RC0603FR-0727RL
R28, R30, R31: 270; R_0603_HandSoldering; MPN RC0603FR-07270RL
R32: 1k; R_0603_HandSoldering; MPN RC0603FR-071KL
TP1: Testpoints; Pin_Header_Straight_1x04; MPN M20-9990446
U1: AMBE3003; TQFP-128_14x14mm_Pitch0.4mm; MPN AMBE-3003
U2: TPS75005RGW_wPin21; QFN-20-1EP_5x5mm_Pitch0.65mm; MPN TPS75005RGWT
U3: FT232RL; SSOP-28_5.3x10.2mm_Pitch0.65mm; MPN FT232RL-REEL
X1: 29.4912; Oscillator_SMD_SeikoEpson_SG210-4pin_2.5x2.0mm; MPN SG-210STF 29.4912ML3

Connections:
75005_RESET: P5.1, R21.2, U1.113 (RESETn), U2.5
+1V9: C6.1, C8.2, C10.1, C12.1, C15.1, C19.1, C21.1, C24.1, J4.2, R2.1, U1.20 (1V9), U1.29 (1V9), U1.42 (1V9), U1.56 (1V9), U1.63 (1V9), U1.74 (1V9), U1.82 (1V9), U1.94 (1V9), U1.102 (1V9), U1.110 (1V9), U1.114 (1V9), U2.14, U2.15, X1.4 (Vcc)
+5V: C5.1, C27.1, C28.1, C29.1, L1.2, P4.3, P6.3, R22.2, R28.1, R30.1, R31.1, U2.18, U2.19, U3.20 (VCC)
/ADCRESEXT: R5.2, U1.16 (ADCRESEXT)
/D+: C16.2, J2.3 (D+), R25.2
/D-: C13.1, J2.2 (D-), R26.2
/EC_ENABLE: P8.3, R11.1
/ES_ENABLE: P8.2, R10.1
/SK_ENABLE: P8.1, R9.1
/VBUS: C18.1, J2.1 (VBUS), L1.1
/_3V3FL: C1.1, R1.2, U1.52 (3v3FL)
/_CODEC_RESETn: R8.2, U1.60 (CODEC_RESETn)
/_CP_ENABLE: P2.11, U1.8 (CP_ENABLE)
/_CP_SELECT: P2.10, U1.9 (CP_SELECT)
/_DTX_ENABLE: P2.13, U1.5 (DTX_ENABLE)
/_EC_ENABLE: R11.2, U1.120 (EC_ENABLE)
/_ES_ENABLE: R10.2, U1.119 (ES_ENABLE)
/_I2C_CLK: R7.2, U1.71 (I2C_CLK)
/_I2C_DATA: R6.2, U1.70 (I2C_DATA)
/_IDLE: TP1.2, U1.45 (IDLE)
/_IF_SELECT0: P2.16, U1.2 (IF_SELECT0)
/_IF_SELECT1: P2.15, U1.3 (IF_SELECT1)
/_IF_SELECT2: P2.14, U1.4 (IF_SELECT2)
/_McBSP_CLKR: J1.5, U1.21 (McBSP_CLKR)
/_McBSP_CLKX: J1.8, U1.23 (McBSP_CLKX)
/_McBSP_FSR: J1.6, U1.24 (McBSP_FSR)
/_McBSP_FSX: J1.7, U1.22 (McBSP_FSX)
/_McBSP_RxD: J1.1, U1.18 (McBSP_RxD)
/_McBSP_TxD: J1.3, U1.19 (McBSP_TxD)
/_NS_ENABLE: P2.12, U1.7 (NS_ENABLE)
/_RATE0: P2.1, U1.126 (RATE0)
/_RATE1: P2.2, U1.125 (RATE1)
/_RATE2: P2.3, U1.124 (RATE2)
/_RATE3: P2.4, U1.123 (RATE3)
/_RATE4: P2.5, U1.122 (RATE4)
/_RATE5: P2.6, U1.121 (RATE5)
/_RUN: TP1.3, U1.61 (RUN)
/_SK_ENABLE: R9.2, U1.6 (SK_ENABLE)
/_SPI_CLK: R12.2, U1.27 (SPI_CLK)
/_SPI_CLK_IN: R18.2, U1.86 (SPI_CLK_IN)
/_SPI_FSn: R17.2, U1.80 (SPI_FSn)
/_SPI_GENSTE: R16.2, U1.77 (SPI_GENSTE)
/_SPI_RX_DATA: R14.2, U1.31 (SPI_RX_DATA)
/_SPI_STE: R13.2, U1.28 (SPI_STE)
/_SPI_TX_DATA: R15.2, U1.32 (SPI_TX_DATA)
/_SPI_WAKE: R19.2, U1.106 (SPI_WAKE)
/_STANDBY: TP1.1, U1.44 (STANDBY)
/_S_COM_RATE0: P2.9, U1.89 (S_COM_RATE0)
/_S_COM_RATE1: P2.8, U1.90 (S_COM_RATE1)
/_S_COM_RATE2: P2.7, U1.91 (S_COM_RATE2)
/_VREF_1V: C2.1, U1.10 (VREF_1V)
/_VREF_2V: C3.1, U1.11 (VREF_2V)
/_X1/CLKIN: R20.2, U1.58 (X1/CLKIN)
CODEC_RESETn: J1.2, J4.8, R8.1
FT232_RESET: R32.2, U3.2 (DTR)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.1, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.1, C17.2, C18.2, C19.2, C20.2, C21.2, C22.2, C23.2, C24.2, C25.2, C26.2, C27.2, C28.2, C29.2, D1.1 (K), J1.4, J2.5 (GND), J2.6 (Shield), J4.10, P1.1, P1.2, P1.3, P1.4, P1.5, P1.6, P1.7, P1.8, P1.9, P1.10, P1.11, P1.12, P1.13, P1.14, P1.15, P1.16, P1.17, P4.1, P6.1, P9.1, P9.2, P9.3, Q1.2 (E), R3.2, R5.1, R33.2, TP1.4, U1.12 (GND), U1.15 (GND), U1.17 (GND), U1.26 (GND), U1.30 (GND), U1.39 (GND), U1.48 (PPT_ACK), U1.53 (GND), U1.59 (GND), U1.62 (GND), U1.73 (GND), U1.88 (GND), U1.95 (GND), U1.97 (GND), U1.103 (GND), U1.109 (GND), U1.115 (GND), U1.117 (GND), U1.127 (GND)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
I2C_CLK: J4.6, R7.1
I2C_DATA: J4.4, R6.1
unnamed: C4.1, R2.2, R3.1, U2.16
unnamed: C22.1, U3.17 (3V3OUT)
unnamed: D1.2 (A), R28.2
unnamed: D2.1 (K), U3.23 (CBUS0)
unnamed: D2.2 (A), R30.2
unnamed: D3.1 (K), U3.22 (CBUS1)
unnamed: D3.2 (A), R31.2
unnamed: P4.2, U2.9
unnamed: P5.2, Q1.3 (C)
unnamed: P6.2, U2.8
unnamed: Q1.1 (B), R32.1, R33.1
unnamed: R13.1, R16.1
unnamed: R20.1, X1.3 (OUT)
unnamed: R4.1, R22.1, U2.17
unnamed: R25.1, U3.15 (USBD+)
unnamed: R26.1, U3.16 (USBD-)
PARITY_ENABLE: P2.17, U1.79 (N/C)
PWREN: R4.2, U3.14 (CBUS3)
SPI_CLK: J4.3, R12.1, R18.1
SPI_FSn: J4.9, R17.1, R19.1
SPI_RX_DATA: J4.5, R14.1
SPI_TX_DATA: J4.7, R15.1
UART_RTS: U1.64 (RTS), U3.11 (CTS)
UART_RX: U1.43 (PKT_RX_WAKE), U1.112 (UART_RX), U3.1 (TXD)
UART_TX: R27.2, U1.111 (UART_TX), U3.5 (RXD)

Notes on the sheet:
PWR

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
Board: 2 copper layers, 95.0 x 85.0 mm, 82 parts (0 on the bottom side), 84 nets.

Other parts of the board:
OSHW_COPPER_10MM: VAL**; OSHW_COPPER_10MM

## Commit log

2017-05-17 First shot
2017-05-17 Add meta information and resolve some errors
2017-05-17 Add PWR LED and some labels
2017-05-17 Add voltage regulators for 1v9 and 3v3
2017-05-17 Add custom components
2017-05-17 Add AMBE3003 symbol
2017-05-17 Add AMBE3003 chip to schematic
2017-05-17 Add jumpers for AMBE3003 and some refactoring
2017-05-18 Add Rs and Cs to USB connection
2017-05-18 Refactor USB connection and drop 3v3 regulator
2017-05-23 Add reset circuit
2017-05-24 Added support for AMBE3000; Added 3v3 Regulator; Added Codec Connections
2017-05-24 Annotate PCB
2017-05-24 Refactoring and re-configured some pins
2017-05-26 Re-organized Codec Connector
2017-05-26 Added footprints
2017-05-26 Added Netlist
2017-05-26 Initial PCB
2017-05-26 PCB Work In Progress
2017-05-26 Align capacitor values
2017-05-26 Change Cap footprint to case A
2017-05-26 Component Placement Done
2017-06-07 Routed some signal pins, 1v9 and 3v3
2017-06-08 Add outline
2017-06-08 Make outline a little thinner
2017-06-08 Add GND zones
2017-06-08 Refactor all unconnected pins
2017-06-08 Reorder some descriptors
2017-06-08 Rounded corners, added descriptors
2017-06-08 Add OSHW logo and realign jumpers
2017-06-08 Added nice net names / labels
2017-06-08 Add some more labels
2017-06-09 Refactor schematic (moved C24)
2017-06-09 Add LED colors and descriptors to board
2017-06-09 Change footprint of USB connector
2017-06-09 Add BOM for resistors
2017-06-09 Add BOM for 5.1 resistor
2017-06-09 Add BOM for ICs
2017-06-09 Add BOM for pin headers
2017-06-09 Add BOM for FT232RL
2017-06-09 BOMming the EPSON XO
2017-06-09 Add BOM for Cs with n capacitance
2017-06-09 Change units for caps to make BOM work
2017-06-09 Add BOMs for capacitors
2017-06-09 Add BOM and footprint for AMBE3003
2017-06-10 Add BOM info for AMBE3003
2017-06-10 Add a picture and BOM as csv
2017-06-12 Re-add mounting holes
2017-06-17 Better reverse RX/TX LEDs
2017-06-17 Re-route the PCB layout
2017-06-17 Add Testpad for GND
2017-06-17 Re-add OSH logo and TOP/BOT icons
2017-06-17 Refactor schematic a little
2017-06-18 Increase clearance to 0.3mm and refactor whole PCB
2017-06-18 Refactor PCB with 0.3mm clearance
2017-06-18 Refacor PCB with smaller clearance
2017-06-19 USB Shield to GND; Testpoint Descriptions on PCB
2017-06-19 Update BOM for Mouser
2017-06-25 Align to MultiCB doc
2017-07-11 Make config pins "tristate"
2017-08-20 Add PDF for schematics
2017-10-18 Redesign power supply (schematic only)
2017-10-18 Refactor reset path
2017-10-18 Wire DTR to AMBE Reset
2017-10-18 BOM for new power supply
2017-10-18 Clear new PCB for redesign
2017-10-18 Make PARTIY available on jumper header
2017-10-18 Make BCu GND and add thermal pad for TPS75005
2017-10-18 Refactor PCB layout for v1.1
2017-10-18 Add nice logo
2017-10-18 Refactor labels
2017-10-18 Correct polarisation for C6 and C7
2017-10-18 Add pull-up resistor for PWREN signal
2017-10-18 Bump version and date
2017-10-18 Add keepout area for top/bottom markers and add author info
2017-10-18 Remove LICENSE
2017-10-18 Add LICENSE
2017-10-18 Add info about revision 1.1 to README
2017-10-18 Add notes to v1.2 to README
2017-10-18 Add pic to README
2017-10-18 Add/update BOM for version 1.2
2017-10-18 Add Mouser carts for v1.0 and v1.1
2017-10-18 Add Mouser cart for v1.2 board
2017-10-18 Add CC logo to PCB
2017-10-18 Add dimensions for drill holes
2017-10-18 Add dimensions for corners
2017-10-18 Add jumper setting info to board silkscreen
2017-11-11 Correct typo in README
2017-11-21 Move misplaced labels
2018-02-21 Add baseline for 3D case
2018-02-21 Add 3D Case draft
2018-02-22 Move hole for USB connector to the right place
2018-02-22 Tune top part and align base part
